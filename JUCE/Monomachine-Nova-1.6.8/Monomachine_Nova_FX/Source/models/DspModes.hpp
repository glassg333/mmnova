#pragma once
// DSP mode registry -- Monomachine Nova 1.6.5 (ревизия v7)
//
// ЧТО ИЗМЕНИЛОСЬ В v7 (по жалобам пользователя на 1.6.4):
//   * Раздел ROUTE убран из меню DSP MODE: проверенная цепочка одна
//     (synth->dist->srr->filt+eq->env->dsnd), переключатель ничего не менял
//     на слух («если так можно просто удалить mnm роутинг»). Параметр mode_route
//     оставлен в состоянии для совместимости, но в UI не показывается;
//     вместо него -- подробное описание цепочки при наведении (dspRouteDescription).
//   * У FM+STAT удалён резервный old-движок (пользователь разрешил): машина 8
//     всегда использует mnm-ядро; FM-машины разведены по отдельным файлам
//     (monomachine_fm_stat.hpp / monomachine_fm_par.hpp / monomachine_fm_dynamic.hpp).
//   * Тексты меню/тултипов переписаны: категории не перепутаны, каждая строка
//     начинается с имени своего раздела, без лишних подчёркиваний.
// -----------------------------------------------------------------------------
// ГЛАВНОЕ ПРАВИЛО: в каждом разделе свой короткий список режимов,
// первым всегда основной "mnm".
//
// ЧТО ИЗМЕНИЛОСЬ В v6
//   * Альтернативные движки dist2 / fm2 / bbox2 УДАЛЕНЫ вместе с кодом
//     (MnmDist2.hpp, MnmFm2.hpp, MnmBbox2.hpp выведены из сборки в *.bak-v6).
//     Осталось ровно два режима: mnm (основной) и old (прежнее приближение Nova).
//   * Новые режимы теперь есть ТОЛЬКО у фильтра: FILT mnm = реальный фильтр из дампа
//     прошивки (MnmRealFilter.hpp, таблицы kLP 258 коэффициентов, SVF $F528BD/$4A4DF0).
//     Все остальные разделы -- как в 1.6.0: их прежние алгоритмы получили режим old.
//   * Схема состояния 9 -> 10: старые индексы режимов (2/3/4 для новых и 5/6/7 для
//     прежних нумераций) сводятся к основному mnm, см. dspModeLegacyIndexToCurrent.
//
// Числа режимов:
// 0 mnm -- ОСНОВНОЙ: реальный фильтр из прошивки (FILT), ядра прошивки для AMP/DIST/DLY/SYNT
// 1 old -- РЕЗЕРВ: прежние приближения Nova (biquad-фильтр, tanh-дист, линейный дилей...)

#include <array>
#include <cstdint>
#include <cstring>

namespace monomachine {

enum DspSection : int {
    DspSynt = 0,
    DspAmp,
    DspFilter,
    DspDist,
    DspDelay,
    DspRouting,
    DspChorus,
    DspSectionCount
};

inline const char* dspModeParamId(int section) {
    switch (section) {
        case DspSynt:   return "mode_synt";
        case DspAmp:    return "mode_amp";
        case DspFilter: return "mode_filt";
        case DspDist:   return "mode_dist";
        case DspDelay:  return "mode_dly";
        case DspRouting:return "mode_route";
        case DspChorus: return "mode_cho";
        default:        return "mode_unknown";
    }
}

inline const char* dspSectionLabel(int section) {
    switch (section) {
        case DspSynt:   return "SYNT";
        case DspAmp:    return "AMP";
        case DspFilter: return "FILT";
        case DspDist:   return "DIST";
        case DspDelay:  return "DLY";
        case DspRouting:return "ROUTE";
        case DspChorus: return "CHOR";
        default:        return "?";
    }
}

// Полный список режимов. Нужен параметру AudioParameterChoice (значение = индекс),
// поэтому порядок здесь = нумерация выше и меняться не должен.
inline const char* dspModeChoices() { return "mnm|old"; }
inline constexpr int dspModeMnm = 0;
inline constexpr int dspModeOld = 1;
inline constexpr int dspModeCount = 2;

// Версия схемы состояния: 9 -> 10 из-за удаления режимов dist2/fm2/bbox2.
inline constexpr int kDspModeSchemaVersion = 10;

inline const char* dspModeName(int mode) {
    switch (mode) {
        case 0: return "mnm";
        case 1: return "old";
        default: return "?";
    }
}
inline const char* dspModeLabel(int mode) { return dspModeName(mode); }

inline int dspModeIndexByName(const char* name) {
    if (name == nullptr) return -1;
    for (int m = 0; m < dspModeCount; ++m)
        if (std::strcmp(dspModeName(m), name) == 0) return m;
    return -1;
}

// Перевод индексов режимов из состояний с прежними схемами (8 и меньше):
//   0 mnm -> mnm, 1 old -> old,
//   2/3/4 (cascade/dual/raw из старого патча) и 5/6/7 (dist2/fm2/bbox2) -> mnm.
// Так ни одно сохранённое состояние не остаётся с несуществующим режимом.
inline int dspModeLegacyIndexToCurrent(int legacy) noexcept {
    switch (legacy) {
        case 0: return dspModeMnm;
        case 1: return dspModeOld;
        default: return dspModeMnm;
    }
}

// false -> в меню остаются только основные (mnm) режимы, резерв полностью скрыт.
inline constexpr bool kShowBackupModes = true;

// -----------------------------------------------------------------------------
// Списки режимов ПО РАЗДЕЛАМ. Первым всегда "mnm" (основной режим раздела).
// Только эти списки решают, что можно включить в разделе: и меню, и аудио-поток
// читают их.
// -----------------------------------------------------------------------------
inline const char* dspSectionModeChoices(int section) {
    switch (section) {
        case DspSynt:    return "mnm|old";   // синт: FmCore прошивки, резерв -- прежний Nova FM
        case DspAmp:     return "mnm|old";   // амплитуда: kernel ADSR-таблицы
        case DspFilter:  return "mnm|old";   // фильтр: РЕАЛЬНЫЙ дамп прошивки, резерв -- прежнее приближение
        case DspDist:    return "mnm|old";   // дист: ALU-сатурация прошивки, резерв -- прежний bipolarDist
        case DspDelay:   return "mnm|old";   // дилей: m32 FX-DLY
        case DspRouting: return "mnm";       // цепочка проверена и она одна
        case DspChorus:  return "mnm";       // хорус: единственная реализация (ядро OS 1.32B)
        default:         return "mnm";
    }
}

inline int dspSectionModeCount(int section) {
    const char* list = dspSectionModeChoices(section);
    int n = 0;
    for (const char* p = list; *p != 0; ++p) if (*p == '|') ++n;
    return n + 1;
}

// i-й режим раздела (0 = основной mnm). Если индекса нет -- возвращает mnm.
inline int dspSectionModeAt(int section, int index) {
    const char* list = dspSectionModeChoices(section);
    int i = 0;
    const char* start = list;
    for (const char* p = list; ; ++p) {
        if (*p == '|' || *p == 0) {
            if (i == index) {
                std::array<char, 16> token{};
                const std::size_t len = static_cast<std::size_t>(p - start);
                const std::size_t n = len < token.size() - 1 ? len : token.size() - 1;
                for (std::size_t k = 0; k < n; ++k) token[k] = start[k];
                const int mode = dspModeIndexByName(token.data());
                return mode < 0 ? dspModeMnm : mode;
            }
            ++i;
            if (*p == 0) break;
            start = p + 1;
        }
    }
    return dspModeMnm;
}

// Единственное правило допустимости: режим должен быть в списке своего раздела.
inline bool dspModeAllowedForSection(int section, int mode) {
    const int n = dspSectionModeCount(section);
    for (int i = 0; i < n; ++i) if (dspSectionModeAt(section, i) == mode) return true;
    return false;
}

// Основной режим раздела -- всегда mnm и всегда доступен.
inline constexpr int dspModePrimaryForSection(int) { return dspModeMnm; }

// Совместимость с прежним кодом.
inline constexpr int dspModeFilter = DspFilter;

// -----------------------------------------------------------------------------
// Категории (папки) меню DSP MODE: чтобы было видно, к чему относится каждый
// раздел и какие машины/ручки он обслуживает (просьба пользователя:
// «дсп должны быть отсортированы по папкам, чтобы понимать зависимость»).
// -----------------------------------------------------------------------------
inline const char* dspSectionCategory(int section) {
    switch (section) {
        case DspSynt:    return "\xd0\x9c\xd0\x90\xd0\xa8\xd0\x98\xd0\x9d\xd0\xab (OSC)";   // FM+ STAT/PAR/DYN и остальные осцилляторы
        case DspAmp:     return "\xd0\x90\xd0\x9c\xd0\x9f\xd0\x9b\xd0\x98\xd0\xa2\xd0\xa3\xd0\x94\xd0\x90";      // ручка DIST/VOL страницы AMP + огибающая
        case DspFilter:  return "\xd0\xa4\xd0\x98\xd0\x9b\xd0\xac\xd0\xa2\xd0\xa0";         // страница FILT: BASE/WDTH/HPQ/LPQ/ATK/DEC/BOFS/WOFS
        case DspDist:    return "\xd0\x94\xd0\x98\xd0\xa1\xd0\xa2\xd0\x9e\xd0\xa0\xd0\xa8\xd0\x9d/SRR";   // ручка DIST (страница AMP) + SRR (страница EFFX)
        case DspDelay:   return "\xd0\x94\xd0\x98\xd0\x9b\xd0\x95\xd0\x99";          // страница EFFX: DTIM/DSND/DFB/DBAS/DWID
        case DspRouting: return "\xd0\xa6\xd0\x95\xd0\x9f\xd0\xac";           // порядок блоков (один, проверенный)
        case DspChorus:  return "\xd0\xa5\xd0\x9e\xd0\xa0\xd0\xa3\xd0\xa1";          // машина FX-CHORUS (15)
        default:         return "";
    }
}

// 1.6.5: ROUTE больше не выбирается в меню -- цепочка одна и проверена.
// Раздел остаётся в состоянии (mode_route) только для совместимости пресетов.
inline bool dspSectionVisibleInMenu(int section) { return section != DspRouting; }

// -----------------------------------------------------------------------------
// Тексты (меню/тултипы). Каждая строка начинается с имени СВОЕГО раздела,
// чтобы категории больше не могли «перепутаться». Константы резонанса --
// реальные из прошивки: $F528BD = -0.084747577, $4A4DF0 = +0.581161499.
// -----------------------------------------------------------------------------
inline const char* dspModeProvenance(int section) {
    switch (section) {
        case DspSynt:   return "SYNT: mnm = \xd1\x8f\xd0\xb4\xd1\x80\xd0\xbe FM+ \xd0\xb8\xd0\xb7 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8 OS 1.32B (P:$4A8-$4F5, \xd1\x82\xd0\xbe\xd0\xbd LP P:$144AC7). old = \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 Nova FM (\xd1\x83 FM+STAT \xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2\xd0\xb0 \xd0\xbd\xd0\xb5\xd1\x82, \xd0\xbc\xd0\xb0\xd1\x88\xd0\xb8\xd0\xbd\xd0\xb0 8 \xd0\xb2\xd1\x81\xd0\xb5\xd0\xb3\xd0\xb4\xd0\xb0 \xd0\xbd\xd0\xb0 mnm)";
        case DspAmp:    return "AMP: mnm = \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f-\xd0\xb0\xd0\xb2\xd1\x82\xd0\xbe\xd0\xbc\xd0\xb0\xd1\x82 \xd0\xb8\xd0\xb7 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8, \xd1\x82\xd0\xb0\xd0\xb1\xd0\xbb\xd0\xb8\xd1\x86\xd1\x8b Y:$141800 (\xd0\xb0\xd1\x82\xd0\xb0\xd0\xba\xd0\xb0) \xd0\xb8 Y:$141880 (\xd0\xb4\xd0\xb5\xd0\xba\xd0\xb5\xd0\xb9/\xd1\x80\xd0\xb5\xd0\xbb\xd0\xb8\xd0\xb7). old = \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd1\x8f\xd1\x8f \xd0\xb0\xd0\xbf\xd0\xbf\xd1\x80\xd0\xbe\xd0\xba\xd1\x81\xd0\xb8\xd0\xbc\xd0\xb0\xd1\x86\xd0\xb8\xd1\x8f Nova \xd1\x81 \xd0\xba\xd1\x80\xd0\xb8\xd0\xb2\xd1\x8b\xd0\xbc\xd0\xb8";
        case DspFilter: return "FILT: mnm = \xd0\xbd\xd0\xb0\xd1\x81\xd1\x82\xd0\xbe\xd1\x8f\xd1\x89\xd0\xb8\xd0\xb9 \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80 \xd0\xb8\xd0\xb7 \xd0\xb4\xd0\xb0\xd0\xbc\xd0\xbf\xd0\xb0 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8 (258 \xd0\xba\xd0\xbe\xd1\x8d\xd1\x84\xd1\x84. P:$144AC7, SVF $F528BD/$4A4DF0, \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f BOFS/WOFS, \xd0\xbf\xd1\x80\xd0\xb8 \xd0\xb4\xd0\xb5\xd1\x84\xd0\xbe\xd0\xbb\xd1\x82\xd0\xb5 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xb5\xd0\xbd). old = \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 biquad";
        case DspDist:   return "DIST: mnm = \xd0\xbd\xd0\xb0\xd1\x81\xd1\x8b\xd1\x89\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb5 \xd0\xba\xd0\xb0\xd0\xba \xd0\xb2 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb5 (\xd0\xb6\xd1\x91\xd1\x81\xd1\x82\xd0\xba\xd0\xb8\xd0\xb9 \xd0\xba\xd0\xbb\xd0\xb8\xd0\xbf +-1.0, 64 = \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xbd\xd0\xbe). old = \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 tanh/bipolar";
        case DspDelay:  return "DLY: mnm = \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb8\xd1\x8f m32 FX-DLY (\xd0\xb1\xd1\x83\xd1\x84\xd0\xb5\xd1\x80 X:$114000, \xd1\x82\xd0\xb0\xd0\xb1\xd0\xbb\xd0\xb8\xd1\x86\xd0\xb0 \xd0\xb2\xd1\x80\xd0\xb5\xd0\xbc\xd1\x91\xd0\xbd P:$144C49), wet \xd0\xbe\xd1\x82\xd0\xb4\xd0\xb5\xd0\xbb\xd1\x8c\xd0\xbd\xd1\x8b\xd0\xbc \xd1\x81\xd0\xb8\xd0\xb3\xd0\xbd\xd0\xb0\xd0\xbb\xd0\xbe\xd0\xbc, DSND=0 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xbd\xd0\xbe. old = \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb5\xd0\xb9\xd0\xbd\xd0\xb0\xd1\x8f \xd0\xb8\xd0\xbd\xd1\x82\xd0\xb5\xd1\x80\xd0\xbf\xd0\xbe\xd0\xbb\xd1\x8f\xd1\x86\xd0\xb8\xd1\x8f, DSND \xd0\xb2\xd0\xbb\xd0\xb5\xd0\xb2\xd0\xbe = \xd0\xbf\xd0\xb8\xd0\xbd\xd0\xb3-\xd0\xbf\xd0\xbe\xd0\xbd\xd0\xb3, \xd0\xb2\xd0\xbf\xd1\x80\xd0\xb0\xd0\xb2\xd0\xbe = \xd1\x81\xd1\x82\xd0\xb5\xd1\x80\xd0\xb5\xd0\xbe";
        case DspRouting:return "ROUTE: \xd1\x86\xd0\xb5\xd0\xbf\xd0\xbe\xd1\x87\xd0\xba\xd0\xb0 \xd0\xbe\xd0\xb4\xd0\xbd\xd0\xb0 \xd0\xb8 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb2\xd0\xb5\xd1\x80\xd0\xb5\xd0\xbd\xd0\xb0: synth->dist->srr->filt+eq->env->dsnd. \xd0\x9f\xd0\xb5\xd1\x80\xd0\xb5\xd0\xba\xd0\xbb\xd1\x8e\xd1\x87\xd0\xb0\xd1\x82\xd0\xb5\xd0\xbb\xd1\x8c \xd1\x83\xd0\xb1\xd1\x80\xd0\xb0\xd0\xbd \xd0\xb8\xd0\xb7 \xd0\xbc\xd0\xb5\xd0\xbd\xd1\x8e \xd0\xb2 1.6.5";
        case DspChorus: return "CHOR: mnm = \xd0\xbd\xd0\xb0\xd1\x82\xd0\xb8\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb5 \xd1\x8f\xd0\xb4\xd1\x80\xd0\xbe OS 1.32B (24-bit), INP \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb5\xd0\xb9\xd0\xbd\xd1\x8b\xd0\xb9, \xd0\xbc\xd0\xb8\xd0\xba\xd1\x81 dry->wet \xd0\xbf\xd0\xbe MIX";
        default:        return "";
    }
}

inline const char* dspModeProvenanceForMode(int section, int mode) {
    if (mode == dspModeMnm) {
        switch (section) {
            case DspSynt:    return "SYNT mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd1\x8f\xd0\xb4\xd1\x80\xd0\xbe FM+ \xd0\xb8\xd0\xb7 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8 OS 1.32B (P:$4A8-$4F5, \xd1\x82\xd0\xbe\xd0\xbd LP P:$144AC7)";
            case DspAmp:     return "AMP mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f-\xd0\xb0\xd0\xb2\xd1\x82\xd0\xbe\xd0\xbc\xd0\xb0\xd1\x82 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8, \xd1\x82\xd0\xb0\xd0\xb1\xd0\xbb\xd0\xb8\xd1\x86\xd1\x8b Y:$141800/Y:$141880";
            case DspFilter:  return "FILT mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xbd\xd0\xb0\xd1\x81\xd1\x82\xd0\xbe\xd1\x8f\xd1\x89\xd0\xb8\xd0\xb9 \xd0\xb4\xd0\xb0\xd0\xbc\xd0\xbf \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8, 258 \xd0\xba\xd0\xbe\xd1\x8d\xd1\x84\xd1\x84. + SVF $F528BD/$4A4DF0, Q 0.5..16, \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f BOFS/WOFS, \xd0\xbf\xd1\x80\xd0\xb8 \xd0\xb4\xd0\xb5\xd1\x84\xd0\xbe\xd0\xbb\xd1\x82\xd0\xb5 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xb5\xd0\xbd";
            case DspDist:    return "DIST mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xbd\xd0\xb0\xd1\x81\xd1\x8b\xd1\x89\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb5 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8 bset #$14,sr (\xd0\xb6\xd1\x91\xd1\x81\xd1\x82\xd0\xba\xd0\xb8\xd0\xb9 \xd0\xba\xd0\xbb\xd0\xb8\xd0\xbf +-1.0)";
            case DspDelay:   return "DLY mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb8\xd1\x8f m32 FX-DLY X:$114000 + P:$144C49, wet \xd0\xbe\xd1\x82\xd0\xb4\xd0\xb5\xd0\xbb\xd1\x8c\xd0\xbd\xd0\xbe, \xd0\xbf\xd1\x80\xd0\xb8 DSND=0 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xbd\xd0\xb0";
            case DspRouting: return "ROUTE (\xd0\xb5\xd0\xb4\xd0\xb8\xd0\xbd\xd1\x81\xd1\x82\xd0\xb2\xd0\xb5\xd0\xbd\xd0\xbd\xd1\x8b\xd0\xb9): synth->dist->srr->filt+eq->env->dsnd (\xd0\xbf\xd1\x80\xd0\xbe\xd0\xb2\xd0\xb5\xd1\x80\xd0\xb5\xd0\xbd\xd0\xbe)";
            case DspChorus:  return "CHOR mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xbd\xd0\xb0\xd1\x82\xd0\xb8\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb5 \xd1\x8f\xd0\xb4\xd1\x80\xd0\xbe OS 1.32B 24-bit, \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb5\xd0\xb9\xd0\xbd\xd1\x8b\xd0\xb9 INP, \xd0\xbc\xd0\xb8\xd0\xba\xd1\x81 dry->wet";
            default:         return "mnm (\xd0\xbe\xd1\x81\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbd\xd0\xbe\xd0\xb9): \xd0\xb2\xd0\xbe\xd1\x81\xd1\x81\xd1\x82\xd0\xb0\xd0\xbd\xd0\xbe\xd0\xb2\xd0\xbb\xd0\xb5\xd0\xbd\xd0\xbd\xd0\xb0\xd1\x8f \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb0";
        }
    }
    if (mode == dspModeOld) {
        switch (section) {
            case DspSynt:    return "SYNT old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 Nova FM. \xd0\x92\xd0\xbd\xd0\xb8\xd0\xbc\xd0\xb0\xd0\xbd\xd0\xb8\xd0\xb5: \xd1\x83 FM+STAT \xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2 \xd1\x83\xd0\xb4\xd0\xb0\xd0\xbb\xd1\x91\xd0\xbd \xd0\xb2 1.6.5, \xd0\xbc\xd0\xb0\xd1\x88\xd0\xb8\xd0\xbd\xd0\xb0 8 \xd0\xbe\xd1\x81\xd1\x82\xd0\xb0\xd1\x91\xd1\x82\xd1\x81\xd1\x8f \xd0\xbd\xd0\xb0 mnm";
            case DspAmp:     return "AMP old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd1\x8f\xd1\x8f \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f Nova \xd1\x81 \xd0\xba\xd1\x80\xd0\xb8\xd0\xb2\xd1\x8b\xd0\xbc\xd0\xb8 ATK/DEC/REL";
            case DspFilter:  return "FILT old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 biquad-\xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80 Nova";
            case DspDist:    return "DIST old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb8\xd0\xb9 tanh/bipolar \xd0\xb4\xd0\xb8\xd1\x81\xd1\x82";
            case DspDelay:   return "DLY old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbb\xd0\xb8\xd0\xbd\xd0\xb5\xd0\xb9\xd0\xbd\xd0\xb0\xd1\x8f \xd0\xb8\xd0\xbd\xd1\x82\xd0\xb5\xd1\x80\xd0\xbf\xd0\xbe\xd0\xbb\xd1\x8f\xd1\x86\xd0\xb8\xd1\x8f; DSND \xd0\xb2\xd0\xbb\xd0\xb5\xd0\xb2\xd0\xbe = \xd0\xbf\xd0\xb8\xd0\xbd\xd0\xb3-\xd0\xbf\xd0\xbe\xd0\xbd\xd0\xb3, \xd0\xb2\xd0\xbf\xd1\x80\xd0\xb0\xd0\xb2\xd0\xbe = \xd1\x81\xd1\x82\xd0\xb5\xd1\x80\xd0\xb5\xd0\xbe";
            case DspChorus:  return "CHOR old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbd\xd0\xb5 \xd0\xb8\xd1\x81\xd0\xbf\xd0\xbe\xd0\xbb\xd1\x8c\xd0\xb7\xd1\x83\xd0\xb5\xd1\x82\xd1\x81\xd1\x8f, \xd1\x8f\xd0\xb4\xd1\x80\xd0\xbe \xd0\xbe\xd0\xb4\xd0\xbd\xd0\xbe";
            default:         return "old (\xd1\x80\xd0\xb5\xd0\xb7\xd0\xb5\xd1\x80\xd0\xb2): \xd0\xbf\xd1\x80\xd0\xb5\xd0\xb6\xd0\xbd\xd0\xb5\xd0\xb5 \xd0\xbf\xd1\x80\xd0\xb8\xd0\xb1\xd0\xbb\xd0\xb8\xd0\xb6\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb5 Nova";
        }
    }
    return "?";
}

// -----------------------------------------------------------------------------
// 1.6.5: подробное описание цепочки для наведения на строчку роутинга
// (тултип кнопки DSP MODE и справка в меню). Объясняет, КАК каждый блок
// влияет на звук и почему при ручках «по умолчанию» FX не меняет источник.
// -----------------------------------------------------------------------------
inline const char* dspRouteDescription() {
    return
        "\xd0\xa6\xd0\x95\xd0\x9f\xd0\xac (\xd0\xbe\xd0\xb4\xd0\xbd\xd0\xb0, \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb2\xd0\xb5\xd1\x80\xd0\xb5\xd0\xbd\xd0\xb0, \xd0\xba\xd0\xb0\xd0\xba \xd0\xb2 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb5 OS 1.32B):\n"
        "1) SYNTH/\xd0\xbc\xd0\xb0\xd1\x88\xd0\xb8\xd0\xbd\xd0\xb0 -> \xd0\xb8\xd1\x81\xd1\x82\xd0\xbe\xd1\x87\xd0\xbd\xd0\xb8\xd0\xba \xd0\xb7\xd0\xb2\xd1\x83\xd0\xba\xd0\xb0 (FM+, SWAVE, SID, FX-\xd0\xbc\xd0\xb0\xd1\x88\xd0\xb8\xd0\xbd\xd1\x8b...).\n"
        "2) DIST: \xd0\xbd\xd0\xb0\xd1\x81\xd1\x8b\xd1\x89\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb5. \xd0\xa0\xd1\x83\xd1\x87\xd0\xba\xd0\xb0 DIST=64 \xd0\xbf\xd0\xbe\xd0\xbb\xd0\xbd\xd0\xbe\xd1\x81\xd1\x82\xd1\x8c\xd1\x8e \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xbd\xd0\xb0, \xd0\xbd\xd0\xb8\xd0\xb6\xd0\xb5 64 \xd0\xbe\xd1\x81\xd0\xbb\xd0\xb0\xd0\xb1\xd0\xbb\xd1\x8f\xd0\xb5\xd1\x82 \xd0\xb4\xd1\x80\xd0\xb0\xd0\xb9\xd0\xb2, \xd0\xb2\xd1\x8b\xd1\x88\xd0\xb5 \xd0\xb4\xd0\xbe\xd0\xb1\xd0\xb0\xd0\xb2\xd0\xbb\xd1\x8f\xd0\xb5\xd1\x82 \xd0\xbf\xd0\xb5\xd1\x80\xd0\xb5\xd0\xb3\xd1\x80\xd1\x83\xd0\xb7.\n"
        "3) SRR: \xd0\xbf\xd0\xbe\xd0\xbd\xd0\xb8\xd0\xb6\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb5 \xd1\x87\xd0\xb0\xd1\x81\xd1\x82\xd0\xbe\xd1\x82\xd1\x8b \xd0\xb4\xd0\xb8\xd1\x81\xd0\xba\xd1\x80\xd0\xb5\xd1\x82\xd0\xb8\xd0\xb7\xd0\xb0\xd1\x86\xd0\xb8\xd0\xb8 (\xd1\x80\xd1\x83\xd1\x87\xd0\xba\xd0\xb0 SRR=0 \xd0\xb2\xd1\x8b\xd0\xba\xd0\xbb\xd1\x8e\xd1\x87\xd0\xb5\xd0\xbd\xd0\xb0) -> \xd0\xb7\xd0\xb5\xd1\x80\xd0\xbd\xd0\xb8\xd1\x81\xd1\x82\xd0\xbe\xd1\x81\xd1\x82\xd1\x8c \xd0\xbf\xd1\x80\xd0\xb8 \xd0\xbf\xd0\xbe\xd0\xb2\xd1\x8b\xd1\x88\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb8.\n"
        "4) FILT+EQ: \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x88\xd0\xb8\xd0\xb2\xd0\xba\xd0\xb8 (BASE/WDTH/HPQ/LPQ + \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f BOFS/WOFS), \xd0\xb7\xd0\xb0\xd1\x82\xd0\xb5\xd0\xbc \xd0\xbf\xd0\xb8\xd0\xba-EQ (EQF/EQG). \xd0\x9f\xd1\x80\xd0\xb8 BASE=0/WDTH=127/Q=0 \xd0\xb8 EQG=0 \xd0\xbf\xd1\x80\xd0\xbe\xd0\xb7\xd1\x80\xd0\xb0\xd1\x87\xd0\xb5\xd0\xbd.\n"
        "5) ENV: \xd0\xb0\xd0\xbc\xd0\xbf\xd0\xbb\xd0\xb8\xd1\x82\xd1\x83\xd0\xb4\xd0\xbd\xd0\xb0\xd1\x8f \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f (ATK/HOLD/DEC/REL). \xd0\x92 FX-\xd0\xb2\xd0\xb5\xd1\x80\xd1\x81\xd0\xb8\xd0\xb8 \xd0\xbf\xd1\x80\xd0\xb8 LATCH \xd0\xb4\xd0\xb5\xd1\x80\xd0\xb6\xd0\xb8\xd1\x82\xd1\x81\xd1\x8f \xd0\xbe\xd1\x82\xd0\xba\xd1\x80\xd1\x8b\xd1\x82\xd0\xbe\xd0\xb9, \xd0\xbf\xd1\x80\xd0\xb8 MIDI gate \xd1\x81\xd0\xbb\xd0\xb5\xd0\xb4\xd1\x83\xd0\xb5\xd1\x82 \xd0\xb7\xd0\xb0 \xd0\xbd\xd0\xbe\xd1\x82\xd0\xb0\xd0\xbc\xd0\xb8.\n"
        "6) DSND: \xd0\xbf\xd0\xbe\xd1\x81\xd1\x8b\xd0\xbb \xd0\xb2 \xd0\xb4\xd0\xb8\xd0\xbb\xd0\xb5\xd0\xb9 \xd0\x9f\xd0\x9e\xd0\xa1\xd0\x9b\xd0\x95 \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80\xd0\xb0 \xd0\xb8 \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb5\xd0\xb9. DSND=0 \xd0\xbf\xd0\xbe\xd1\x81\xd1\x8b\xd0\xbb \xd0\xb2\xd1\x8b\xd0\xba\xd0\xbb\xd1\x8e\xd1\x87\xd0\xb5\xd0\xbd, \xd0\xb2\xd1\x8b\xd1\x85\xd0\xbe\xd0\xb4 = \xd1\x81\xd1\x83\xd1\x85\xd0\xbe\xd0\xb9 \xd1\x81\xd0\xb8\xd0\xb3\xd0\xbd\xd0\xb0\xd0\xbb \xd0\xb1\xd0\xb5\xd0\xb7 \xd0\xb8\xd0\xb7\xd0\xbc\xd0\xb5\xd0\xbd\xd0\xb5\xd0\xbd\xd0\xb8\xd0\xb9.\n"
        "\xd0\x98\xd1\x82\xd0\xbe\xd0\xb3: \xd0\xbf\xd1\x80\xd0\xb8 DIST=64, SRR=0, \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80\xd0\xb5/EQ \xd0\xbf\xd0\xbe \xd1\x83\xd0\xbc\xd0\xbe\xd0\xbb\xd1\x87\xd0\xb0\xd0\xbd\xd0\xb8\xd1\x8e \xd0\xb8 DSND=0 \xd1\x86\xd0\xb5\xd0\xbf\xd0\xbe\xd1\x87\xd0\xba\xd0\xb0 unity, \xd1\x82\xd0\xbe \xd0\xb5\xd1\x81\xd1\x82\xd1\x8c \xd0\xbd\xd0\xb5 \xd0\xbc\xd0\xb5\xd0\xbd\xd1\x8f\xd0\xb5\xd1\x82 \xd0\xb3\xd1\x80\xd0\xbe\xd0\xbc\xd0\xba\xd0\xbe\xd1\x81\xd1\x82\xd1\x8c \xd0\xb8 \xd1\x82\xd0\xb5\xd0\xbc\xd0\xb1\xd1\x80 \xd0\xb8\xd1\x81\xd1\x82\xd0\xbe\xd1\x87\xd0\xbd\xd0\xb8\xd0\xba\xd0\xb0.\n"
        "\xd0\x9f\xd0\xbe\xd1\x80\xd1\x8f\xd0\xb4\xd0\xbe\xd0\xba \xd0\xb2\xd0\xb0\xd0\xb6\xd0\xb5\xd0\xbd: \xd0\xb4\xd0\xb8\xd1\x81\xd1\x82 \xd0\xb4\xd0\xbe \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80\xd0\xb0 (\xd0\xbf\xd0\xb5\xd1\x80\xd0\xb5\xd0\xb3\xd1\x80\xd1\x83\xd0\xb7 \xd1\x80\xd0\xb5\xd0\xb6\xd0\xb5\xd1\x82\xd1\x81\xd1\x8f \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80\xd0\xbe\xd0\xbc), \xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f \xd0\xbf\xd0\xbe\xd1\x81\xd0\xbb\xd0\xb5 \xd1\x84\xd0\xb8\xd0\xbb\xd1\x8c\xd1\x82\xd1\x80\xd0\xb0 (\xd0\xbe\xd0\xb3\xd0\xb8\xd0\xb1\xd0\xb0\xd1\x8e\xd1\x89\xd0\xb0\xd1\x8f \xd0\xbd\xd0\xb5 \xd0\xbc\xd0\xbe\xd0\xb4\xd1\x83\xd0\xbb\xd0\xb8\xd1\x80\xd1\x83\xd0\xb5\xd1\x82 \xd1\x81\xd1\x80\xd0\xb5\xd0\xb7), \xd0\xb4\xd0\xb8\xd0\xbb\xd0\xb5\xd0\xb9 \xd0\xb2 \xd0\xba\xd0\xbe\xd0\xbd\xd1\x86\xd0\xb5 (\xd0\xbf\xd0\xbe\xd0\xb2\xd1\x82\xd0\xbe\xd1\x80\xd1\x8b \xd0\xbd\xd0\xb5 \xd0\xbf\xd1\x80\xd0\xbe\xd1\x85\xd0\xbe\xd0\xb4\xd1\x8f\xd1\x82 \xd1\x87\xd0\xb5\xd1\x80\xd0\xb5\xd0\xb7 \xd0\xb4\xd0\xb8\xd1\x81\xd1\x82).";
}

}  // namespace monomachine

