// ============================================================================
// MnmFixed.h — арифметика DSP56300 в терминах C++ (Monomachine SFX-60 OS 1.32B)
// ============================================================================
// Правила верности звуку:
//  * слова 24-бит Q1.23 (1 знак, 23 дробных), $7FFFFF = 1.0, $800000 = -1.0;
//  * умножение ДРОБНОЕ знаковое со сдвигом влево на 1 (mpy/mac): (a*b)<<1 >> 24;
//  * "сатурация" в прошивке включается bset #$14,sr (SR.SM / bit20) — АЛУ клипует
//    на ±1.0 в 24-битном слове. Здесь это sat24. НЕ заменять float-клипом:
//    на горячих участках поведение 56-битного аккумулятора и 24-битного слова
//    различается слышимо.
//  * деление — 24-битная итеративная схема `do #<$18 ; div` (P:$0586 и др.):
//    частное накапливается в a0, делимое 8/2^23 и т.п. Эквивалент — s24div ниже.
// ============================================================================
#pragma once
#include <cstdint>
#include <algorithm>

namespace mnmsys {

using s24 = int32_t;   // контейнер Q1.23

constexpr s24 Q23_ONE   = 0x7FFFFF;
constexpr s24 Q23_MINUS = -0x800000;   // 0x800000 как знаковое = -1.0 (!)

inline s24 sat24(int64_t v) noexcept
{
    if (v >  0x7FFFFF) return  0x7FFFFF;
    if (v < -0x800000) return -0x800000;
    return (s24) v;
}

// дробное знаковое умножение DSP56300: результат (a*b)<<1 в Q1.23
// 56-битный аккумулятор НЕ сатурирует внутри MAC-цепочки — сатурация
// происходит при ЗАПИСИ 24-битного слова. Здесь fmpy — «умножение + запись».
inline s24 fmpy(s24 a, s24 b) noexcept
{
    const int64_t p = int64_t(a) * int64_t(b);
    // (a*b) - 46-битный продукт Q2.46; <<1 -> Q1.47; берём верхние 24 бита
    int64_t r = p << 1;                      // Q1.47
    r >>= 24;                                // Q1.23
    return sat24(r);
}

// mpy + accumulate: a = sat(a + b*c<<1)
inline s24 fmac(s24 acc, s24 a, s24 b) noexcept
{
    return sat24(acc + ((int64_t(a) * int64_t(b)) >> 22));
}

// 24-шаговое деление `do #<$18; div` (частное в a0, знаковое, делимое < делителя)
// Эквивалент непрерывного Q1.23 деления с насыщением.
inline s24 s24div(s24 num, s24 den) noexcept
{
    if (den == 0) return (num >= 0) ? Q23_ONE : Q23_MINUS;
    int64_t n = int64_t(num) << 23;
    int64_t d = den;
    // знаковое деление с округлением к нулю, потом сатурация
    int64_t q = n / d;
    return sat24(q);
}

inline float q23ToF(uint32_t v) noexcept
{
    int32_t s = (v & 0x800000u) ? int32_t(v | 0xFF000000u) : int32_t(v);
    return float(s) / 8388608.0f;
}

// ВАЖНО: возвращает ЗНАКОВОЕ Q1.23 в int32 (не маскируйте на 24 бита —
// иначе отрицательные значения станут положительными при записи в s24!)
inline s24 fToQ23(float x) noexcept
{
    if (x >  0.99999988f) return  0x7FFFFF;
    if (x < -1.0f)        return -0x800000;
    return int32_t(__builtin_lroundf(x * 8388608.0f));
}

} // namespace mnmsys
