// ============================================================================
// mnm_dist.h — Monomachine DIST: драйв-энвелоп + слот per-machine обработчика
//
// Порт с уровня инструкций (OS 1.32B, ядро DSP1):
//   - драйв-энвелоп:  P:$04FF–$0536 (стейт-машина 0=ATK 1=HOLD 2=DEC)
//   - тимбр-индекс:   P:$0537–$0556 (уровень драйва масштабирует индекс
//                     в таблицу тембра $143546 — «глубина» дисторшна)
//   - слот обработчика: X:(page+$0C), диспетч P:$097B–$0980:
//     ПОСЛЕ резонанса/AMP-гейна, ДО стадии-2; эпилог обработчика jmp $000981
//
// Верификация (итерация 23, probe23d_vectors.json):
//   шаг атаки == kEnvAtk[DIST] БИТ-В-БИТ для DIST ∈ {16,32,64,96,127};
//   DIST=0: 0.5 → wrap −1.0 → DEC → кламп 0 (см. tick());
//   траектории уровня/фазы/индекса сняты с бит-точного эмулятора.
//
// Использование: tick() раз в кадр (16 сэмплов @44.1к); уровень драйва
// подставляйте в timbreIndex() перед лукапом таблицы тембра $143546.
// ============================================================================
#pragma once
#include <cstdint>
#include <cmath>
#include <algorithm>

#include "mnm_tables.h"

namespace mnm {

// ----------------------------------------------------------------------------
// kDistRel — P:$141A00 (128 слов), шаг линейного спада драйва за кадр.
// Индекс = rnd((VOL² + $7FFF) >> 16); ячейка y:(page+$0D) перезаписывается
// ядром каждый кадр — замер: VOL=127 → 16129 = 127²  → индекс 0 → 1/64/кадр.
// ----------------------------------------------------------------------------
inline constexpr std::array<float, 128> kDistRel = {
    0.015625f, 0.0147670507f, 0.0139559507f, 0.0131900311f, 0.0124659538f, 0.0117809772f,
    0.0111340284f, 0.0105229616f, 0.00994503498f, 0.00939905643f, 0.00888299942f, 0.00839495659f,
    0.00793397427f, 0.00749897957f, 0.00708699226f, 0.00669801235f, 0.00633001328f, 0.00598299503f,
    0.00565397739f, 0.00534403324f, 0.00504994392f, 0.00477302074f, 0.00451099873f, 0.0042630434f,
    0.00402903557f, 0.00380802155f, 0.00359904766f, 0.00340104103f, 0.00321400166f, 0.00303804874f,
    0.00287103653f, 0.00271296501f, 0.0025639534f, 0.00242400169f, 0.00229096413f, 0.00216495991f,
    0.00204598904f, 0.00193405151f, 0.00182700157f, 0.00172698498f, 0.00163197517f, 0.00154304504f,
    0.00145804882f, 0.00137805939f, 0.00130200386f, 0.00123095512f, 0.00116300583f, 0.00109899044f,
    0.00103902817f, 0.000982046127f, 0.000928044319f, 0.000877022743f, 0.0008289814f, 0.000782966614f,
    0.00074005127f, 0.000699996948f, 0.000661015511f, 0.000625014305f, 0.000591039658f, 0.000558018684f,
    0.000527977943f, 0.000499010086f, 0.000470995903f, 0.000445008278f, 0.000421047211f, 0.000398039818f,
    0.000375986099f, 0.000355005264f, 0.000336050987f, 0.000316977501f, 0.000300049782f, 0.000283002853f,
    0.000267982483f, 0.000252962112f, 0.000239014626f, 0.000226020813f, 0.000213980675f, 0.000201940536f,
    0.000190973282f, 0.000180006027f, 0.000170946121f, 0.00016105175f, 0.000151991844f, 0.000144004822f,
    0.000136017799f, 0.000128984451f, 0.000121951103f, 0.000115036964f, 0.000108957291f, 0.000102996826f,
    9.70363617e-05f, 9.20295715e-05f, 8.70227814e-05f, 8.20159912e-05f, 7.7009201e-05f, 7.29560852e-05f,
    6.90221786e-05f, 6.49690628e-05f, 6.19888306e-05f, 5.8054924e-05f, 5.49554825e-05f, 5.19752502e-05f,
    4.8995018e-05f, 4.69684601e-05f, 4.39882278e-05f, 4.19616699e-05f, 3.89814377e-05f, 3.69548798e-05f,
    3.50475311e-05f, 3.30209732e-05f, 3.09944153e-05f, 3.0040741e-05f, 2.8014183e-05f, 2.59876251e-05f,
    2.50339508e-05f, 2.39610672e-05f, 2.20537186e-05f, 2.0980835e-05f, 2.00271606e-05f, 1.8954277e-05f,
    1.80006027e-05f, 1.70469284e-05f, 1.59740448e-05f, 1.50203705e-05f, 1.39474869e-05f, 1.29938126e-05f,
    1.29938126e-05f, 0.0f,
};

namespace raw {
// 24-битная signed-арифметика Q1.23 — как аккумулятор DSP (a1 = биты 23..0).
inline int32_t wrap24(int32_t v) noexcept
{
    v &= 0xFFFFFF;
    return (v & 0x800000) ? (v - 0x1000000) : v;
}
inline int32_t q23(float x) noexcept { return (int32_t) lrintf(x * 8388608.0f); }
} // namespace raw

// ----------------------------------------------------------------------------
// MonoMachineDistDrive — драйв-энвелоп DIST (бит-точный порт P:$04FF–$0536).
//
// Фазы (ячейка y:(page+$DB)):
//   0 = ATK : level += kEnvAtk[DIST]   (add y0,b; EC-переход = 24-битный wrap)
//   1 = HOLD: счётчик X:(page+$DA), выход при counter+eps >= counter·2·$791FD0
//             (практически 1 кадр — замер итер. 23)
//   2 = DEC : level -= kDistRel[idx]; idx = rnd((VOL² + $7FFF)>>16);
//             clr b ifmi  → level клампится в 0 при отрицательном значении
//             (поэтому wrap'нутый −1.0 умирает мгновенно — замер подтверждает)
//
// Ретриг: при y:(page+$20)==1 ядро обнуляет уровень/фазу/счётчик ($0500–$0505)
// — атака начинается заново с текущего нуля.
//
// Уровень ПОСЛЕ wrap'а отрицательный — это не ошибка, так в железе: уровень
// идёт 0…+1, перескакивает в −1 и спадает к 0 (знак — «внутренняя кухня»,
// сравни с AMP-энвелопом, 06_amp_env). Индекс тембра использует знак как есть.
// ----------------------------------------------------------------------------
class MonoMachineDistDrive
{
public:
    struct Params
    {
        int dist = 0;    // DIST-ручка 0..127 (ячейка y:(page+$0C), биты 23..16)
        int vol = 127;   // VOL 0..127 → ядро пишет VOL² в y:(page+$0D) (замер)
    };

    // Фазы — как в железе
    enum Phase : int { kAtk = 0, kHold = 1, kDec = 2 };

    void reset() noexcept { phase = kAtk; level = 0; counter = 0; }

    // Ретриг-ячейка y:(page+$20): 1 → сброс (вызывается, когда машина/хост ставит 1)
    void retrig() noexcept { phase = kAtk; level = 0; counter = 0; }

    // Один кадр (16 сэмплов). Возвращает СЫРОЙ уровень Q1.23 (может быть < 0
    // после wrap'а — см. комментарий класса).
    int32_t tickRaw (const Params& p) noexcept
    {
        using namespace raw;
        switch (phase)
        {
        case kAtk: {
            const int32_t inc = (int32_t) lrintf(kEnvAtk[p.dist & 127] * 8388608.0f);
            const int32_t sum = level + inc;           // add y0,b
            if (sum > 0x7FFFFF) {                      // EC set → wrap
                level = wrap24(sum);                   // −1.0-зона
                phase = kHold;
                counter = q23(1.0f);
            } else {
                level = sum;                           // bec → обычный сторе
            }
            break;
        }
        case kHold:                                  // P:$0517–$052A
            // b = 0·tempo·… = 0 (x0 = 0 от clr a) → counter+eps >= 0 всегда
            // → фаза := 2 и bra $052B — ПАДЕНИЕ В DEC В ТОМ ЖЕ КАДРЕ
            // (замер итер. 23: wrap → −1.0 → 0 за один шаг, f1→f2)
            phase = kDec;
            [[fallthrough]];
        case kDec: default: {                          // P:$052B–$0536
            const int32_t cell = (p.vol & 127) * (p.vol & 127);   // VOL² (замер)
            const int idx = (cell + 0x7FFF) >> 16;                // +rnd
            int32_t b = level - (int32_t) lrintf(kDistRel[idx & 127] * 8388608.0f);
            if (b < 0) b = 0;                           // clr b ifmi
            level = b;
            break;
        }
        }
        return level;
    }

    // Удобная обёртка: нормированный уровень (1.0 = «полный драйв»)
    float tick (const Params& p) noexcept { return tickRaw(p) / 8388608.0f; }

    int   getPhase() const noexcept { return phase; }
    int32_t getLevelRaw() const noexcept { return level; }

private:
    int     phase = 0;
    int32_t level = 0;      // X:(page+$DB), signed Q1.23
    int32_t counter = 0;    // X:(page+$DA)
};

// ----------------------------------------------------------------------------
// Тимбр-индекс секции F3 (P:$0537–$0556) — как уровень драйва «открывает»
// таблицу тембра $143546 (1728 слов = 16 полос × 108; чётные входы пар).
//
// Все промежуточные результаты идут через 24-битный a1-срез аккумулятора —
// включая |term|: (panTerm+$C00000) считается в 56-битном акк., abs — там же,
// но в множитель попадает a1 = младшие 24 бита СО ЗНАКОМ. При panTerm = 0:
// |0+$C00000| = 0.75 → a1 = 0xC00000 → ЗНАКОВОЙ −0.5! Квадрат 0.25, asl#2 →
// 1.0 → a1 = 0x800000 = −1.0 — ЕЩЁ ОДИН переворот знака. Итог: при нулевом
// param4 индекс = −$80 − drive·1792 (ОТРИЦАТЕЛЬНЫЙ, скользит вниз с драйвом).
// Эмулятор (probe23d, DIST=64, кадр 70): drive=1418083 → idx = −431 = 0xFFFE51 —
// формула даёт ровно −303−128 = −431. БИТ-В-БИТ.
// ----------------------------------------------------------------------------
inline int timbreIndex (int32_t driveRaw, int32_t param4Raw,
                        int32_t panTermRaw) noexcept
{
    using namespace raw;
    const int64_t base = (int64_t) param4Raw * 0x800 - 0x80; // mpyi/sub: 56-бит, без wrap
    int32_t s = panTermRaw + 0xC00000;                       // add: 56-бит, без wrap
    if (s < 0) s = -s;                                       // abs (56-бит)
    const int32_t t = wrap24(s);                             // a1 → y0 (знаковый срез!)
    const int32_t v1 = wrap24((((int64_t) t * t) >> 23) << 2); // mpy; asl#2; a1
    const int32_t v2 = wrap24((int64_t) driveRaw * v1 >> 23);  // mpy y1,y0; a1 → y1
    const int32_t v3 = wrap24((int64_t) v2 * 0x700 >> 23);     // mpy y1,x1; a1
    const int64_t acc = v3 + base;                             // add b,a
    if (acc >= 0x700) return 0x700;                            // tfr x1,a ifge
    return wrap24((int32_t)(acc & 0xFFFFFF));                  // сторе a1
}

// ----------------------------------------------------------------------------
// MonoMachineDistSlot — контракт слота per-machine обработчика (X:(page+$0C)).
//
// Диспетч ядра P:$097B–$0980 (между резонансом и стадией-2):
//   r6 += $28; a = x:(r6−$1C); tst a; beq → чистый путь; jmp (r0)
//   кадр: r7 = page+$15C. Эпилог обработчика: jmp $000981 (r6 -= $28).
//
// Слот ставит ХОСТ/CONF машины каждый кадр (ядро обнуляет его на старте
// кадра $0000DB; CONF вызывается каждый кадр $00FB–$00FF). Пример: m14
// SWAVE-ENS пишет $145C48 ($145C44–$145C46).
//
// Найденный обработчик $145C48–$145CCE (SWAVE-семейство), структура:
//   - fade-in: счётчик y:(r6+$34) < 64 → гейн ветки 0, иначе 1.0;
//   - стейт y:(r6+$32) = 0.95·стейт + 0.05·param5 (one-pole, mpyi $066666/
//     maci $79999A); y:(r6+$33) = f(param5,param6); глобаль y:$C4 = 1−стейт;
//   - комплексный вращатель 16 ступеней над банками X:$20-$2F/X:$30-$3F
//     (bset/bclr #$14,sr — параллельный ход), x0=$EF;
//   - кольцо 1024 слова (маска m0=$3FF, указатель y:(r6+$36)) — взвешенные
//     суммы 8+8 тапов (вес $40) с шин X:$00-$0F / X:$10-$1F в кольцо;
//   - финальный микш 16 тапов с билинейными весами Y:$C0-$C7 (mpy/mac
//     над x:(r0)/x:(r1)/x:(r2)/x:(r3) банками) → выходные банки.
//
// В JUCE: наследуйте и реализуйте process() — вызывайте между фильтром
// и стадией-2, когда машина «вооружает» слот.
// ----------------------------------------------------------------------------
class MonoMachineDistSlot
{
public:
    virtual ~MonoMachineDistSlot() = default;

    // Вызвать ПОСЛЕ резонансной секции, ДО стадии-2 (позиция $097B).
    // fade(): первые 64 кадра после arm() гейн ветки = 0 (анти-щелчок).
    void arm() noexcept { fadeCtr = 0; armed = true; }
    void disarm() noexcept { armed = false; }

    bool isActive() const noexcept { return armed; }
    float fade() const noexcept { return fadeCtr >= 64 ? 1.0f : 0.0f; }

    // Один кадр тракта: вызвать process() если слот вооружён (как jmp (r0)),
    // затем обновить счётчик фейда (add #>$1 при < $40, P:$145C4A–$145C51).
    void run() noexcept
    {
        if (! armed) return;
        if (fadeCtr < 64) { ++fadeCtr; process(); return; } // clr b ветка
        process();
    }

protected:
    virtual void process() noexcept = 0;   // тело обработчика машины

private:
    bool armed = false;
    int  fadeCtr = 0;                      // y:(r6+$34)
};

} // namespace mnm
